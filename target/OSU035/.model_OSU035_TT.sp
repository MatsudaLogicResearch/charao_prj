.inc /home/synology_nfs/Techlibs/Techlib/OSU035/TT/nmos.sp
.inc /home/synology_nfs/Techlibs/Techlib/OSU035/TT/pmos.sp

* .TEMP 25
