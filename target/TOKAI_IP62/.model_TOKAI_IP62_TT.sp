**===================================================================
** This file is associated with the charao project.
** Copyright (C) 2025 MATSUDA Masahiro
**
** This configuration file is licensed under the MIT License.
**===================================================================

.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/model/ip62_models

* .TEMP 27
