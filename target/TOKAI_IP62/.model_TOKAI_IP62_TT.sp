.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/model/ip62_models

* .TEMP 27
