*.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/IP62_PDK_230721/models/models_IP62_mos_v5
*.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/models_IP62_mos_v5.ngspice

.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/model/ngspice/models_IP62_v6.l
.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/model/ngspice/models_IP62_mos_v5.l
.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/model/ngspice/models_IP62res_v4.l
* .TEMP 25
