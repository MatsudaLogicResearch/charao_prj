*.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/IP62_PDK_230721/models/models_IP62_mos_v5
.inc /home/synology_nfs/Techlibs/Techlib/TOKAIR/ip62/models_IP62_mos_v5.ngspice

* .TEMP 25
