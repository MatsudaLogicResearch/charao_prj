**===================================================================
** This file is associated with the charao project.
** Copyright (C) 2025 MATSUDA Masahiro
**
** This configuration file is licensed under the MIT License.
**===================================================================

.inc ../src/OSU035/FF/nmos.sp
.inc ../src/OSU035/FF/pmos.sp

* .TEMP -40
